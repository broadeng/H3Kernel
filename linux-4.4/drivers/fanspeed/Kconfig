## linux-4.4/drivers/fanspeed/Kconfig
```kconfig
config FAN_SPEED_DETECT
    tristate "fan speed detect support"
    help
      This enables support for the fan speed detection module
```
